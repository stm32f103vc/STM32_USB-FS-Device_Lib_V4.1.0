# IAR project SysTick.ewp, settings and files
configuration STM3210E-EVAL (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103ZE ST STM32F103ZE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STM3210E_EVAL; STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM3210E_EVAL
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM3210E-EVAL_SysTick.bin
  ILINK.IlinkOutputFile: SysTick.out
  ILINK.IlinkIcfFile: stm32f103xe_flash_offset.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM3210B-EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103VB ST STM32F103VB
  ICCARM.CCDefines: USE_STM3210B_EVAL; STM32F10X_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include; ..\..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM3210B_EVAL
  OBJCOPY.OOCOutputFile: STM3210B-EVAL_SysTick.bin
  ILINK.IlinkIcfFile: stm32f103xb_flash_offset.icf
configuration STM3210E-EVAL_XL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103ZG ST STM32F103ZG
  ICCARM.CCDefines: USE_STM3210E_EVAL; STM32F10X_XL; USE_STDPERIPH_DRIVER
  OBJCOPY.OOCOutputFile: STM3210E_XL_SysTick.bin
  ILINK.IlinkIcfFile: stm32f103xg_flash_offset.icf
configuration STM32L152_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152VB ST STM32L152VB
  ICCARM.CCDefines: USE_STM32L152_EVAL; STM32L1XX_MD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM32L152_EVAL
  OBJCOPY.OOCOutputFile: STM32L152-EVAL_SysTick.bin
  ILINK.IlinkIcfFile: stm32l1xx_flash_offset.icf
configuration STM32L152D_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32L152ZD ST STM32L152ZD
  ICCARM.CCDefines: USE_STM32L152D_EVAL; STM32L1XX_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32L1xx\Include; ..\..\..\..\Libraries\STM32L1xx_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM32L152D_EVAL
  OBJCOPY.OOCOutputFile: STM32L152-EVAL_SysTick.bin
  ILINK.IlinkIcfFile: stm32l1xx_flash_offset.icf
configuration STM32373C_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F373VC ST STM32F373VC
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F37X; USE_STM32373C_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F37x\Include; ..\..\..\..\Libraries\STM32F37x_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM32373C_EVAL
  OBJCOPY.OOCOutputFile: STM32373C_EVAL_SysTick.bin
  ILINK.IlinkIcfFile: stm32f37x_flash_offset.icf
configuration STM32303C_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F303VC ST STM32F303VC
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; USE_STM32303C_EVAL
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\Libraries\CMSIS\Device\ST\STM32F30x\Include; ..\..\..\..\Libraries\STM32F30x_StdPeriph_Driver\inc; ..\..\..\..\Utilities\STM32_EVAL; ..\..\..\..\Utilities\STM32_EVAL\Common; ..\..\..\..\Utilities\STM32_EVAL\STM32303C_EVAL
  OBJCOPY.OOCOutputFile: STM32303C_EVAL_SysTick.bin
  ILINK.IlinkIcfFile: stm32f303xc_flash_offset.icf
configuration STM32303xE_EVAL (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F303VE ST STM32F303VE
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F30X; USE_STM32303C_EVAL
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: STM32303C_EVAL_SysTick.bin
  ILINK.IlinkIcfFile: stm32f303xe_flash_offset.icf
configuration STM32F302x8_Nucleo (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F302R8 ST STM32F302R8
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F302x8; USE_NUCLEO
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: STM32F302x8_Nucleo.bin
  ILINK.IlinkIcfFile: stm32f302x8_flash_offset.icf
  group Doc
    ../: readme.txt
  group STM32F10x/CMSIS
    ./: startup_stm32f10x_hd.s startup_stm32f10x_md.s startup_stm32f10x_xl.s
    ../../src/: system_stm32f10x.c
  group STM32F10x/STM3210B_EVAL
    ../../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval.c
  group STM32F10x/STM3210E_EVAL
    ../../../../Utilities/STM32_EVAL/STM3210E_EVAL/: stm3210e_eval.c
  group STM32F10x/STM32F10x_StdPeriph_Driver
    ../../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c
  group STM32F30x/CMSIS
    ./: startup_stm32f302x8.s startup_stm32f303xc.s startup_stm32f303xe.s
    ../src/: system_stm32f30x.c
  group STM32F30x/STM32303C_EVAL
    ../../../../Utilities/STM32_EVAL/STM32303C_EVAL/: stm32303c_eval.c
  group STM32F30x/STM32F30x_StdPeriph_Driver
    ../../../../Libraries/STM32F30x_StdPeriph_Driver/src/: stm32f30x_dma.c stm32f30x_exti.c stm32f30x_flash.c stm32f30x_gpio.c stm32f30x_i2c.c stm32f30x_misc.c stm32f30x_pwr.c stm32f30x_rcc.c stm32f30x_spi.c stm32f30x_syscfg.c stm32f30x_usart.c
  group STM32F37x/CMSIS
    ./: startup_stm32f37x.s
    ../src/: system_stm32f37x.c
  group STM32F37x/STM32373C_EVAL
    ../../../../Utilities/STM32_EVAL/STM32373C_EVAL/: stm32373c_eval.c
  group STM32F37x/STM32F37x_StdPeriph_Driver
    ../../../../Libraries/STM32F37x_StdPeriph_Driver/src/: stm32f37x_dma.c stm32f37x_exti.c stm32f37x_flash.c stm32f37x_gpio.c stm32f37x_i2c.c stm32f37x_misc.c stm32f37x_pwr.c stm32f37x_rcc.c stm32f37x_spi.c stm32f37x_syscfg.c stm32f37x_usart.c
  group STM32L1xx/CMSIS
    ./: startup_stm32l1xx_hd.s startup_stm32l1xx_md.s
    ../../src/: system_stm32l1xx.c
  group STM32L1xx/STM32L152_EVAL
    ../../../../Utilities/STM32_EVAL/STM32L152_EVAL/: stm32l152_eval.c
  group STM32L1xx/STM32L152D_EVAL
    ../../../../Utilities/STM32_EVAL/STM32L152D_EVAL/: stm32l152d_eval.c
  group STM32L1xx/STM32L1xx_StdPeriph_Driver
    ../../../../Libraries/STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_rcc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_usart.c
  group User
    ../src/: main.c stm32_it.c
