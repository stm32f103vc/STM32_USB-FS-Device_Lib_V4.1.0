# Keil uVision project Project.uvprojx, settings and files
target STM3210B-EVAL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM3210B-EVAL +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,USE_STM3210B_EVAL
  c misc: --C99
  c include: ../inc;../../../Libraries/CMSIS/Device/ST/STM32F10x/Include;../../../Libraries/STM32_USB-FS-Device_Driver/inc;../../../Libraries/STM32F10x_StdPeriph_Driver/inc;../../../Utilities/STM32_EVAL;../../../Utilities/STM32_EVAL/Common;../../../Utilities/STM32_EVAL/STM3210B_EVAL;..\nrf24l01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USB-FS-Device_Driver
    ../../../Libraries/STM32_USB-FS-Device_Driver/src/: usb_sil.c usb_regs.c usb_int.c usb_core.c usb_mem.c usb_init.c
  group STM32F10x/STM3210B_EVAL
    ../../../Utilities/STM32_EVAL/STM3210B_EVAL/: stm3210b_eval.c
  group User
    ../src/: usb_endp.c usb_desc.c stm32_it.c usb_istr.c usb_pwr.c usb_prop.c hw_config.c main.c
    ../nrf24l01/: bsp_spi_nrf.c nrf_debug_printf.c
  group STM32F10x/CMSIS
    ./: startup_stm32f10x_md.s
    ../src/: system_stm32f10x.c
  group Doc
    ../: readme.txt
  group STM32F10x/STM32F10x_StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_usart.c misc.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_sdio.c
software components: CMSIS:CORE 5.2.0
